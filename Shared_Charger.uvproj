# Keil uVision project Shared_Charger.uvproj, settings and files
target SN8F5702 (MCS-51)
  device: SN8F5702 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: Shared_Charger +hex
  AfterMake: HexConvert.exe $D "#H" FRC
  c flags: Optimize=4 SizeSpeed=1
  group UserApp
    ./: STARTUP.A51 OPTIONS_SN8F5702.A51
    ./Scr/: Main.c Init.c IntGnd.c InChk.c App.c Data.c AD.c Ntc.c Sub.c Tab.c UART.C
